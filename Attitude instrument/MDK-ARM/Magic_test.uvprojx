# Keil uVision project Magic_test.uvprojx, settings and files
target Magic_test (5060960::V5.06 update 7 (build 960)::.\compiler)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Magic_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MDK-ARM;./APP;./DEVICE;./Fusion-main/Fusion;./mavlink_transplant;./mavlink_transplant/common;./mavlink_transplant/minimal;./mavlink_transplant/standard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group APP
    ./APP/: filters.c filters.h ahrs.c ahrs.h mahony.c mahony.h imu_data.c imu_data.h commu.c commu.h
  group FusionAhrs
    ./Fusion-main/Fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group Device
    ./DEVICE/: MPU6050driver.c MPU6050driver.h OLED.c OLED.h OLED_Font.h LED.c LED.h NRF24L01.c NRF24L01.h
  group Mavlink
    ./mavlink_transplant/: checksum.h mavlink_conversions.h mavlink_get_info.h mavlink_helpers.h mavlink_msg_ahrs2.h mavlink_sha256.h mavlink_types.h protocol.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
